# Keil uVision project CPE355ProjectStarter.uvproj, settings and files
target VideoGame (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: CPE355ProjectStarter
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c ST7735.c CPE355ProjectStarter.c Slide.h Slide.c text.c text.h Button.c Button.h random.s random.h Tasks.c functions.c Tasks.h functions.h Variable.h
    ../Lab4_Ritz/: SysTick.h SysTick.c
